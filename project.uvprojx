# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\include;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;.;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\ipc;..\libraries\HAL_Drivers;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\finsh;..\..\..\libcpu\arm\cortex-m4;board;applications;..\..\..\libcpu\arm\common;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
